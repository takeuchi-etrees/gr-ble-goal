options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: perf_test1
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '20'
    max_iter: '4000'
    scale: '0.05'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '4095'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time


      class RangeDetector(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, range=0.1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.range = range
              self.cur_val = 0.0
              self.in_range = False
              self.count = 0
              self.time = 0
              self.seq = 0

          def work(self, input_items, output_items):
              for i in range(len(input_items[0])):
                  if input_items[0][i] < self.cur_val - self.range:
                      self.cur_val = input_items[0][i]
                      self.count = 0
                      self.time = int(time.time()*1000)
                  elif input_items[0][i] > self.cur_val + self.range:
                      self.cur_val = input_items[0][i]
                      self.count = 0
                      self.time = int(time.time()*1000)
                  else:
                      self.cur_val = input_items[0][i]
                      self.count += 1
                  
                  if self.count > 320:
                      output_items[0][i] = 1.0
                  else:
                      output_items[0][i] = 0.0
                      
                  if self.count == 320:
                      tag_key = pmt.intern("in_range")
                      tag_value = pmt.intern("{0}@{1}@{2}".format(self.cur_val, self.time, self.seq))
                      tag_offset = i
                      self.add_item_tag(0, self.nitems_written(0) + tag_offset, tag_key, tag_value)
                      self.seq += 1
                                 
              return len(output_items[0])
    range: '0.007'
  states: {state: disabled}
- name: etreesModule_calcPhaseDiff_0
  id: etreesModule_calcPhaseDiff
  parameters: {}
  states: {}
- name: etreesModule_rangeDetector_0
  id: etreesModule_rangeDetector
  parameters:
    range: '0.1'
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '4095'
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''fast_attack'''
    gain2: '''fast_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.3.10
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e4
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e4
    win: window.WIN_HAMMING
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:3334
    timeout: '100'
  states: {}

connections:
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [blocks_moving_average_xx_0, '0', etreesModule_rangeDetector_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [epy_block_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [etreesModule_calcPhaseDiff_0, '0', blocks_moving_average_xx_0, '0']
- [etreesModule_rangeDetector_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [etreesModule_rangeDetector_0, '0', qtgui_time_sink_x_0, '0']
- [iio_fmcomms2_source_0, '0', low_pass_filter_0_0_0, '0']
- [iio_fmcomms2_source_0, '1', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', etreesModule_calcPhaseDiff_0, '1']
- [low_pass_filter_0_0_0, '0', etreesModule_calcPhaseDiff_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
