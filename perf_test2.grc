options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: gr_ble
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '20'
    max_iter: '4000'
    scale: '0.05'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '16383'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '16383'
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"ble_sync"'
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"010101101011011111011001000101110001"'
    tagname: ble_sync
    threshold: '0'
    type: byte
  states: {}
- name: digital_gfsk_demod_0_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: etreesModule_bleDecoder_0_0
  id: etreesModule_bleDecoder
  parameters:
    uuid: '"d1f1e152-7032-11e6-8b77-86f30ca893d3"'
  states: {}
- name: etreesModule_calcPhaseDiff_0
  id: etreesModule_calcPhaseDiff
  parameters: {}
  states: {}
- name: etreesModule_rangeDetector_0
  id: etreesModule_rangeDetector
  parameters:
    range: '0.1'
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '16383'
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''fast_attack'''
    gain2: '''fast_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.3.10
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e4
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e4
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e5
    win: window.WIN_HAMMING
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: float
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '3000'
    srate: samp_rate / 8
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '7'
    ymin: '-7'
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:3334
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:3333
    timeout: '100'
  states: {}

connections:
- [blocks_moving_average_xx_0, '0', etreesModule_rangeDetector_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tag_gate_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_uchar_to_float_1, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', etreesModule_bleDecoder_0_0, '0']
- [digital_gfsk_demod_0_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [etreesModule_bleDecoder_0_0, '0', blocks_tag_gate_0, '0']
- [etreesModule_calcPhaseDiff_0, '0', blocks_moving_average_xx_0, '0']
- [etreesModule_rangeDetector_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [iio_fmcomms2_source_0, '0', low_pass_filter_0, '0']
- [iio_fmcomms2_source_0, '0', low_pass_filter_0_2, '0']
- [iio_fmcomms2_source_0, '1', low_pass_filter_0_0, '0']
- [low_pass_filter_0, '0', etreesModule_calcPhaseDiff_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [low_pass_filter_0_0, '0', etreesModule_calcPhaseDiff_0, '1']
- [low_pass_filter_0_2, '0', digital_gfsk_demod_0_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_0, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, zeromq_pub_msg_sink_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
