options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: gr_ble
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-40'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-40'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_2
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_correctiq_0_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '100'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo
    type: float
    vlen: '2'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: '0.01'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.1.10
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e5
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e5
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e5
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '6'
    size: '3000'
    srate: samp_rate
    tr_chan: '3'
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '7'
    ymin: '-7'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_streams_to_vector_0, '0']
- [analog_simple_squelch_cc_0, '0', low_pass_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', low_pass_filter_0_1, '0']
- [analog_simple_squelch_cc_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_arg_1, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_complex_to_arg_2, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_arg_2, '0', qtgui_time_sink_x_0_1_0, '4']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_1_0, '3']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_complex_to_float_1, '1', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_float_1, '1', blocks_multiply_xx_0_0_0_0, '0']
- [blocks_complex_to_float_2, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_2, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_complex_to_float_2, '1', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_2, '1', blocks_multiply_xx_0_0_0_0, '1']
- [blocks_correctiq_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_correctiq_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [blocks_delay_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_float_to_complex_0, '0', blocks_complex_to_arg_2, '0']
- [blocks_moving_average_xx_0, '0', blocks_delay_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0_1_0, '5']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_sub_xx_1, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_streams_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_1_0, '2']
- [blocks_sub_xx_1, '0', blocks_float_to_complex_0, '1']
- [iio_fmcomms2_source_0, '0', blocks_correctiq_0, '0']
- [iio_fmcomms2_source_0, '1', blocks_correctiq_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_arg_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_1, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_arg_1, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_float_2, '0']
- [low_pass_filter_0_1, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
